FILESEXTRAPATHS_prepend_poky := "${THISDIR}/files:"

SPLASH_IMAGES := "file://psplash-lotos-img.h;outsuffix=default"
