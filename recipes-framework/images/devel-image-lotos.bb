include recipes-framework/images/core-image-lotos.bb

IMAGE_INSTALL += "\
    curvdemo1     \
    "
