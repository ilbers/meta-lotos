include recipes-framework/images/lotos-image-release.bb

IMAGE_INSTALL += "\
    curvdemo1     \
    "
