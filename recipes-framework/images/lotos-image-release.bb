include recipes-sato/images/core-image-sato.bb

IMAGE_INSTALL += "\
    qtbase        \
    qtbase-fonts  \
    qttools       \
    qwt           \
    "
